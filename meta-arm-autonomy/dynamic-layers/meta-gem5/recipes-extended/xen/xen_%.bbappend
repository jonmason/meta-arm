# Machine specific settings
XEN_CONFIG_EARLY_PRINTK_gem5-arm64 = "vexpress"
