# SPDX-License-Identifier: MIT
#
# Copyright (c) 2019 Arm Limited
#

SRC_URI = "git://git.kernel.org/pub/scm/utils/dtc/dtc.git"

SRCREV = "65cc4d2748a2c2e6f27f1cf39e07a5dbabd80ebf"

LIC_FILES_CHKSUM = "file://GPL;md5=94d55d512a9ba36caa9b7df079bae19f"
