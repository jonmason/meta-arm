# SPDX-License-Identifier: MIT
#
# Copyright (c) 2019 Arm Limited
#

SUMMARY = "Linux Kernel provided and supported by Arm/Linaro"

require recipes-kernel/linux/linux-arm-common.inc
