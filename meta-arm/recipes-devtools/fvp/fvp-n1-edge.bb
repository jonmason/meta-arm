require fvp-ecosystem.inc

MODEL = "Neoverse-N1"
MODEL_CODE = "FVP_RD_N1_edge"
PV = "11.12.43"

SRC_URI[sha256sum] = "e428cc44db251202bf45ae68d40832d01efbc5d0f1323f1ce46237213dd4f0fa"
