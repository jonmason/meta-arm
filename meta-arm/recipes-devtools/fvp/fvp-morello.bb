require fvp-ecosystem.inc

MODEL = "Morello%20Platform"
MODEL_CODE = "FVP_Morello"
PV = "0.11.34"

SRC_URI[sha256sum] = "ed1e110fb7fa8732d4f1bea9af69491a9e3f7dbf57d2ce6ea916d3cdf910d324"

LIC_FILES_CHKSUM = "file://license_terms/license_agreement.txt;md5=1a33828e132ba71861c11688dbb0bd16 \
                    file://license_terms/third_party_licenses.txt;md5=47473b1e04b70938cf0a7ffea8ea4cc3"
