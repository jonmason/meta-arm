require fvp-ecosystem.inc

MODEL = "SGI-575"
MODEL_CODE = "FVP_CSS_SGI-575"
PV = "11.12.59"

SRC_URI[sha256sum] = "86c7a16d83b0801278b4a3d05c8d42c4955ed22a0dbea3c583798fb971bc425c"
