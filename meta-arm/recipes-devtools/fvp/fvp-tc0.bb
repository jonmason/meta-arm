require fvp-ecosystem.inc

MODEL = "TotalCompute"
MODEL_CODE = "FVP_TC0"
PV = "11.15.20"

SRC_URI[sha256sum] = "792ddb425eba0714a1590aa8e404845b7654758c663745693216ae1343ceef2d"

LIC_FILES_CHKSUM = "file://license_terms/license_agreement.txt;md5=a50d186fffa51ed55599183aad911298 \
                    file://license_terms/third_party_licenses.txt;md5=3db0c4947b7e3405c40b943672d8de2f"
