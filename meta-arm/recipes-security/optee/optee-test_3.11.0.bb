require optee-test.inc

SRCREV = "159e295d5cc3ad2275ab15fe544620f6604d4ba4"
