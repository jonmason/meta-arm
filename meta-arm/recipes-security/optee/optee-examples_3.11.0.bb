require optee-examples.inc

SRCREV = "9a7dc598591990349d88b4dba3a37aadd6851295"

