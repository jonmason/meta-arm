require optee-client.inc

SRCREV = "2a77cf88d956c34cb4a1c191bea6113e327f5fe0"
