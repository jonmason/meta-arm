require optee-test.inc

SRCREV = "30481e381cb4285706e7516853495a7699c93b2c"
