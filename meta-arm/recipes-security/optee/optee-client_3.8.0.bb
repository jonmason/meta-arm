require optee-client.inc

SRCREV = "be4fa2e36f717f03ca46e574aa66f697a897d090"
