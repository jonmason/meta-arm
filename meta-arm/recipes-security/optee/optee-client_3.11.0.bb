require optee-client.inc

SRCREV = "c0c925384c1d7e3558d27d2708857482952d7907"
