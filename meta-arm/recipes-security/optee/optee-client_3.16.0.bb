require optee-client.inc

SRCREV = "06db73b3f3fdb8d23eceaedbc46c49c0b45fd1e2"
