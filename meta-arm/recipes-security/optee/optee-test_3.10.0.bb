require optee-test.inc

SRCREV = "30efcbeaf8864d0f2a5c4be593a5411001fab31b"
