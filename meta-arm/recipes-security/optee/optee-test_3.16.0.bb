require optee-test.inc

SRCREV = "1cf0e6d2bdd1145370033d4e182634458528579d"
