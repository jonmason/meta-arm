COMPATIBLE_MACHINE = "qemuarm-m3"
PICOLIBC_LINKERSCRIPT:qemuarm-m3 = "arm.ld"
