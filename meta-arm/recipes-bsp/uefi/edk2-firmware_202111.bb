SRCREV_edk2           ?= "bb1bba3d776733c41dbfa2d1dc0fe234819a79f2"
SRCREV_edk2-platforms ?= "3e73df15730667c46a1e449cca872e7f8861007c"

require edk2-firmware.inc
