SRCREV_edk2           ?= "ef91b07388e1c0a50c604e5350eeda98428ccea6"
SRCREV_edk2-platforms ?= "2620e05c6fade20ef5e1ba69280d09f9e2b3eff6"

require edk2-firmware.inc
