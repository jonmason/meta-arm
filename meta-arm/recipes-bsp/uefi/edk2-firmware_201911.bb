SRCREV_edk2           ?= "bd85bf54c268204c7a698a96f3ccd96cd77952cd"
SRCREV_edk2-platforms ?= "46df7b29afeb846ee664e48949f9c8161abf1f2f"

require edk2-firmware.inc

