SRCREV_edk2           ?= "e1999b264f1f9d7230edf2448f757c73da567832"
SRCREV_edk2-platforms ?= "86984c17d562fc60a6dabbc3a479d79163656a0c"

require edk2-firmware.inc
