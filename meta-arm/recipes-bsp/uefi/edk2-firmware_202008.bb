SRCREV_edk2           ?= "06dc822d045c2bb42e497487935485302486e151"
SRCREV_edk2-platforms ?= "7aab81a35aef7b295e73d7d6dfd528cc812790ed"

require edk2-firmware.inc
