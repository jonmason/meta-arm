SRCREV_edk2           ?= "7b4a99be8a39c12d3a7fc4b8db9f0eab4ac688d5"
SRCREV_edk2-platforms ?= "64394fd2b48f403330feb8f7e954d1cca0822af5"

require edk2-firmware.inc
