SRCREV_edk2           ?= "872f953262d68a11da7bc2fb3ded16df234b8700"
SRCREV_edk2-platforms ?= "46df7b29afeb846ee664e48949f9c8161abf1f2f"

require edk2-firmware.inc
