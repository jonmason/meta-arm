require trusted-firmware-m-2.2.2-src.inc
require trusted-firmware-m-tests.inc
