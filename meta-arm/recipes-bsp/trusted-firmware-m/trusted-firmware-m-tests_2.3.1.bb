require trusted-firmware-m-2.3.1-src.inc
require trusted-firmware-m-tests.inc
