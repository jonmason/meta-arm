# tf-a-tests

SRCREV_FORMAT = "tfa-tests"

SRCREV_tfa-tests = "b3bcf77a65880049e40fa6f1b764a19dbd9faead"

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6175cc0aa2e63b6d21a32aa0ee7d1b4a"

COMPATIBLE_MACHINE = "tc0"
TFA_TESTS_PLATFORM = "tc0"
TFA_TESTS_BUILD_TARGET = "all"
TFA_TESTS_INSTALL_TARGET = "tftf.bin cactus.bin sp_layout.json \
			    cactus.dts cactus-secondary.dts cactus-tertiary.dts"
