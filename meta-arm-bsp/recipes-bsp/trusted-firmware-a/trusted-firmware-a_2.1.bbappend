# Machine specific TFAs

MACHINE_TFA_REQUIRE ?= ""
MACHINE_TFA_REQUIRE_juno = "trusted-firmware-a-juno.inc"

require ${MACHINE_TFA_REQUIRE}
