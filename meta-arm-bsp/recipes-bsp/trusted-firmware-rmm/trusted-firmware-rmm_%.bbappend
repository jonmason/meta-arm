COMPATIBLE_MACHINE:rdv3 = "rdv3"
RMM_CONFIG:rdv3 = "rdv3_defcfg"
SRC_URI:rdv3 = "gitsm://gitlab.arm.com/infra-solutions/reference-design/platsw/tf-rmm.git;protocol=https;branch=refinfra"
SRCREV:rdv3 = "7efb3e0af62f619c355114d80ba48cbb0b13b905"
COMPATIBLE_MACHINE:rdv3r1 = "rdv3r1"
RMM_CONFIG:rdv3r1 = "rdv3r1_defcfg"
SRC_URI:rdv3r1 = "gitsm://gitlab.arm.com/infra-solutions/reference-design/platsw/tf-rmm.git;protocol=https;branch=refinfra"
SRCREV:rdv3r1 = "7efb3e0af62f619c355114d80ba48cbb0b13b905"
