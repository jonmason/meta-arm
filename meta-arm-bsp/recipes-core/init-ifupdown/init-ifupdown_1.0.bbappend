# Use custom interface file for Juno

#
# Enable second network interface on startup
#

FILESEXTRAPATHS_prepend_juno := "${THISDIR}/files/juno:"
