MACHINE_TS_REQUIRE ?= ""
MACHINE_TS_REQUIRE:corstone1000 = "ts-arm-platforms.inc"

require ${MACHINE_TS_REQUIRE}
