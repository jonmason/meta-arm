# Machine specific configurations

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"

require linux-arm-platforms.inc
