# This is only needed until the juno patches are updated to the latest 5.15 release.
LINUX_VERSION:juno = "5.15.72"
SRCREV_machine:juno = "0b628306d1f9ea28c0e86369ce9bb87a47893c9c"
