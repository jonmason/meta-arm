# Add support for Arm Platforms (boards or simulators)

require linux-yocto-arm-platforms.inc
