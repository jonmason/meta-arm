# Machine specific configurations

require linux-arm-platforms.inc
