FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}-5.4:"
SRC_URI += "file://no_ftrace.cfg file://smmuv3.cfg"
